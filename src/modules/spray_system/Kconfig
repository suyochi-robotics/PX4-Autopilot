## src/modules/spray_system/Kconfig
```kconfig
menuconfig MODULES_SPRAY_SYSTEM
	bool "spray_system"
	default n
	---help---
		Enable support for spray system
```
